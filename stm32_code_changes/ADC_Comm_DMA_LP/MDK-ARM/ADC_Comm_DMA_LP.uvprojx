# Keil uVision project ADC_Comm_DMA_LP.uvprojx, settings and files
target UAE_config_SPI_v01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L4R7VITx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UAE_config_SPI_v01 +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L4R7xx,USE_HAL_DRIVER,STM32L4R7xx, ARM_MATH_CM4
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\Middlewares\Third_Party\FatFs\src;..\Drivers\CMSIS\DSP\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Application/MDK-ARM
    ./: startup_stm32l4r7xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c bsp_driver_sd.c fatfs.c sd_diskio.c setup.c scheduler.c optics.c
    ../Inc/: scheduler.h optics.h
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_lptim.c stm32l4xx_hal_ospi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middleware/FatFS
    ../Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff_gen_drv.c ff.h ff_gen_drv.h ffconf_template.h integer.h
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c syscall.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
